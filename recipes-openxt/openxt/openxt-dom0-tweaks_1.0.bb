require recipes-openxt/openxt/openxt-dom0-tweaks.inc

PR="${INC_PR}.0"
